PACKAGE_INSTALL_append = " bash"
